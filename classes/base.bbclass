addtask build
addtask clean
addtask install
